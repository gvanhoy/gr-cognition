<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>epsilon_greedy_loopback</value></param>
<param><key>author</key><value>Hamed Asadi, Garrett Vanhoy</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Epsilon Greedy Loopback</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>125</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>50</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>cognition_epsilon_greedy</key>
<param><key>id</key><value>cognition_epsilon_greedy_0</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>liquiddsp_flex_rx</key>
<param><key>id</key><value>liquiddsp_flex_rx_0</value></param>
</block>
<block>
<key>liquiddsp_flex_tx</key>
<param><key>id</key><value>liquiddsp_flex_tx_0</value></param>
<param><key>inner_code</key><value>0</value></param>
<param><key>modulation</key><value>0</value></param>
<param><key>outer_code</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>liquiddsp_flex_tx_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>liquiddsp_flex_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognition_epsilon_greedy_0</source_block_id><sink_block_id>liquiddsp_flex_tx_0</sink_block_id><source_key>configuration</source_key><sink_key>configuration</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>liquiddsp_flex_rx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>constellation</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>liquiddsp_flex_rx_0</source_block_id><sink_block_id>cognition_epsilon_greedy_0</sink_block_id><source_key>packet_info</source_key><sink_key>packet_info</sink_key></connection>
<connection><source_block_id>liquiddsp_flex_tx_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>pdus</source_key><sink_key>schedule_event</sink_key></connection>
</flow_graph>
